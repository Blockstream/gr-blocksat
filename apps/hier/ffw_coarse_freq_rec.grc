<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ffw_coarse_freq_rec</value></param>
<param><key>category</key><value>[Blockstream]/Synchronizers</value></param>
<param><key>description</key><value>FFT-Based Feedforward Coarse Carrier Frequency Recovery</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Coarse Frequency Recovery</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>abs_cfo_threshold</value></param>
<param><key>label</key><value>Abs CFO Threshold</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Average Alpha</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>comment</key><value>Sample average</value></param>
<param><key>length</key><value>int(1/alpha)</value></param>
<param><key>max_iter</key><value>int(4/alpha)</value></param>
<param><key>scale</key><value>1.0/int(1/alpha)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>comment</key><value>Sample variance</value></param>
<param><key>length</key><value>int(1/alpha)</value></param>
<param><key>max_iter</key><value>int(4/alpha)</value></param>
<param><key>scale</key><value>1.0/int(1/alpha)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>comment</key><value>Map the FFT bin index
to a CFO given in Hz.
The CFO is the frequency
of the FFT bin, divided by 4.</value></param>
<param><key>const</key><value>samp_rate/(fft_len*4)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>comment</key><value>(x - mean(x))^2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>comment</key><value>x - mean(x)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_peak_threshold</value></param>
<param><key>label</key><value>FFT Peak Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import *</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>alpha</value></param>
<param><key>average</key><value>True</value></param>
<param><key>comment</key><value>Inside this block a single-pole
IIR filter is used for averaging
each FFT tone individually.

The filter Z-transform is:

H(z) = alpha*z/(z -(1-alpha))

Its step response reaches
99.9% at approximately
7*(1/alpha).</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>frame_rate</key><value>samp_rate/fft_len</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blockstream_argpeak</key>
<param><key>id</key><value>blockstream_argpeak_0</value></param>
<param><key>comment</key><value>Freq. offset is the
frequency of the FFT
bin where the peak
is found, divided by 4.
Find the peak here
first.</value></param>
<param><key>max_thresh</key><value>fft_peak_threshold</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blockstream_exponentiate_const_cci</key>
<param><key>id</key><value>blockstream_exponentiate_const_cci_0</value></param>
<param><key>exponent</key><value>4</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blockstream_runtime_cfo_ctrl</key>
<param><key>id</key><value>blockstream_runtime_cfo_ctrl_0</value></param>
<param><key>abs_cfo_threshold</key><value>abs_cfo_threshold</value></param>
<param><key>avg_len</key><value>7*int(1/alpha)</value></param>
<param><key>comment</key><value>Again, transitory length
is approx. 7*(1/alpha).</value></param>
<param><key>rf_center_freq</key><value>int(rf_center_freq)</value></param>
</block>
<block>
<key>blockstream_wrap_fft_index</key>
<param><key>id</key><value>blockstream_wrap_fft_index_0</value></param>
<param><key>comment</key><value>Resolve positive and
negative frequencies</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>logpwr_fft</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>cfo_est</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>sym_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_center_freq</value></param>
<param><key>label</key><value>Starting RF Center Freq.</value></param>
<param><key>value</key><value>1e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>v_sink</value></param>
<param><key>stream_id</key><value>freq_offset_est</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>fft_peak_bin_index</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>freq_offset_est</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>fft_peak_bin_index</value></param>
</block>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blockstream_runtime_cfo_ctrl_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>blockstream_runtime_cfo_ctrl_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>v_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blockstream_argpeak_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blockstream_argpeak_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blockstream_exponentiate_const_cci_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blockstream_runtime_cfo_ctrl_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blockstream_wrap_fft_index_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blockstream_exponentiate_const_cci_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blockstream_runtime_cfo_ctrl_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blockstream_wrap_fft_index_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
